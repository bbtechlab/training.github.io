IMAGE_INSTALL += " example-1.0"
